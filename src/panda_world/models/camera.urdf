Commit message: Fixes and improvements

File: src/panda_world/models/camera.urdf (robot description, URDF)
Before this commit: robot camera, 2 links, 1 joints
Joints:
- joint camera_joint: origin xyz=0.5 1 2.2 rpy=0.1 0.9 -1.57 -> xyz=0 1.5 3.2 rpy=0.1 0.9 -1.57
